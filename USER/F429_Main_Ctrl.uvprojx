# Keil uVision project F429_Main_Ctrl.uvprojx, settings and files
target Main_Ctrl (6150000::V6.15::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F429_Main_Ctrl
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: -Wno-invalid-source-encoding
  c include: ..\USER;..\HAL_LIB\Inc;..\HAL_LIB\CMSIS\Inc;..\HARDWARE\Inc;..\FREERTOS_FAT\include;..\FREERTOS_FAT\portable\common;..\FREERTOS\Source\include;..\FREERTOS\Source\portable\GCC\ARM_CM4F;..\USE_LIB\cpu_rate;..\USE_LIB\json;..\SYSTEM\Inc;..\LUA_LIB\src;..\DSP_LIB\Include;..\EMWIN_LIB\INC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\F429_Main_Ctrl.sct
  group USER
    ./: main.c stm32f4xx_it.c stm32f4xx_hal_conf.h EMWIN_Task.c
  group SYSTEM
    ../SYSTEM/Src/: startup_stm32f429xx.s system_stm32f4xx.c stm32f4xx_sys.c clib_redef.c
  group HARDWARE
    ../HARDWARE/Src/: hw_led.c hw_key.c hw_sdram.c hw_cpu_temp.c hw_spiflash.c hw_touch.c
  group FREERTOS
    ../FREERTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FREERTOS/Source/portable/GCC/ARM_CM4F/: port.c
    ../FREERTOS/Source/portable/MemMang/: heap_5.c
    ../FREERTOS/Source/include/: FreeRTOSConfig.h
  group FREERTOS_FAT
    ../FREERTOS_FAT/: ff_crc.c ff_dir.c ff_error.c ff_fat.c ff_file.c ff_format.c ff_ioman.c ff_locking.c ff_memory.c ff_stdio.c ff_string.c ff_sys.c ff_time.c
    ../FREERTOS_FAT/portable/STM32F4xx/: ff_sddisk.c
    ../FREERTOS_FAT/include/: FreeRTOSFATConfig.h
  group USE_LIB
    ../USE_LIB/cpu_rate/: cpu_utils.c
    ../USE_LIB/json/: cJSON.c
  group HAL_LIB
    ../HAL_LIB/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group LUA_LIB
    ../LUA_LIB/src/: lapi.c lauxlib.c lbaselib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
  group EMWIN_LIB
    ../EMWIN_LIB/CONFIG/: GUI_X_FreeRTOS.c GUI_X_Touch_Analog.c GUIConf.c LCDConf_Lin_Template.c
    ../EMWIN_LIB/LIB/: STemWin540_CM4_OS_Keil_ot_ARGB.lib
    ../EMWIN_LIB/INC/: GUIConf.h
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
